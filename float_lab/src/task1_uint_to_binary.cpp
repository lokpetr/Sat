// ---------------------------------------------------------------------------
// Пункт 1. unsigned int -> двоичная строка побитовыми операциями.
// Промежуточный пункт: ничего показывать не нужно, но этот кусок кода
// переиспользуется во ВСЕХ последующих пунктах (2, 3, 4, 5).
// ---------------------------------------------------------------------------
#include <cassert>
#include <cstdint>
#include <iomanip>
#include <iostream>

#include "floatbits.h"

int main() {
    std::cout << "=== 1. unsigned int -> binary (32 бита, со старшими нулями) ===\n\n";

    const uint32_t samples[] = {0u,
                                1u,
                                2u,
                                5u,
                                255u,
                                256u,
                                123456789u,
                                0x80000000u,
                                0xFFFFFFFFu,
                                (1u << 31) | (1u << 3) | 1u};

    // "красивыми столбиками": ширина колонок через setw
    std::cout << "    dec  |     hex  |  bin\n"
              << "---------+----------+---------------------------------\n";
    for (uint32_t v : samples) {
        std::cout << std::setw(8) << v << " | 0x" << std::hex << std::uppercase << std::setw(8)
                  << std::setfill('0') << v << std::setfill(' ') << std::dec << " |  "
                  << to_binary_bits(v) << "\n";
    }

    // ------------------------------------------------------------------
    // Проверка, что три способа из подсказок дают одинаковый результат:
    //   (а) маска + сдвиг x вправо, разбор с МЛАДШИХ битов, потом разворот;
    //   (б) то же самое, но сразу со СТАРШИХ битов (этот и используется в лабе);
    //   (в) битовая маска 1u << i.
    // ------------------------------------------------------------------
    bool all_same = true;
    for (uint32_t v : samples) {
        if (to_binary_bits(v) != to_binary_bits_shift_right(v)) all_same = false;
    }
    std::cout << "\nвсе три способа (сдвиги в обе стороны и битовые маски) дают один и тот же"
              << " результат: " << (all_same ? "да" : "НЕТ") << "\n";

    // Разбор конкретного числа по степеням двойки -- ровно то, что "под капотом".
    const uint32_t x = 123456789u;
    std::cout << "\n" << x << " = " << to_binary_bits(x) << "\n  = ";
    bool first = true;
    for (int i = 31; i >= 0; --i) {
        if ((x >> i) & 1u) {  // тот самый "& 1" после сдвига
            if (!first) std::cout << " + ";
            std::cout << "2^" << i;
            first = false;
        }
    }
    std::cout << "\n";
    return 0;
}
